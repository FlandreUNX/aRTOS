# Keil uVision project ACGrtos.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: MSP432P401R Texas Instruments
  pack: TexasInstruments.MSP432.1.0.3
  cpu: IRAM(0x20000000,0x00010000) IROM(0x00000000,0x00040000) IROM2(0x00200000,0x00004000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ACGrtos
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __MSP432P401R__ TARGET_IS_MSP432P4XX
  c include: ..\os\arch\msp432\driverlib
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x200000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group test
    ./Source/: startup.c
    ../os/: osConfig.h osAPI.h
  group ACGrtos/kernel
    ../os/kernel/: schedule.c schedule.h thread.h thread.c timer.c timer.h
  group ACGrtos/mm
    ../os/mm/: buddy.c buddy.h
  group ACGrtos/lib
    ../os/lib/: list.h ringBuffer.c ringBuffer.h symbolExport.h
  group ACGrtos/arch
    ../os/arch/: hal_cm.c hal_cm.h platform.h
  group ACGrtos/arch/msp432
    ../os/arch/msp432/: msp432.c msp432.h
  group ACGrtos/arch/msp432/devicelib
    ../os/arch/msp432/driverlib/: adc14.c aes256.c comp_e.c cpu.c crc32.c cs.c dma.c flash.c fpu.c gpio.c i2c.c interrupt.c mpu.c pcm.c pmap.c pss.c ref_a.c reset.c rtc_c.c spi.c sysctl.c systick.c timer_a.c timer32.c uart.c wdt_a.c
software components: CMSIS:CORE 5.0.0, Device:Startup 2.2.1
