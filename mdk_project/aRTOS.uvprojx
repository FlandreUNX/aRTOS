# Keil uVision project aRTOS.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F767ZITx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.7.0
  cpu: IRAM(0x20020000,0x60000) IRAM2(0x20000000,0x20000) IROM(0x08000000,0x200000) IROM2(0x00200000,0x200000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: aRTOS
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F767xx
  c include: ..\os;..\os\arch\STM32F7xx
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20020000 size 0x60000
  memory RVCT10: RAM 0x20000000 size 0x20000
  group test
    ./Source/: startup.c
  group aRTOS/kernel
    ../os/kernel/: idle.c irq.c irq.h schedule.c schedule.h thread.c thread.h timer.c timer.h
  group aRTOS/pm
    ../os/pm/: event.h
  group aRTOS/mm
    ../os/mm/: buddy.c buddy.h
  group aRTOS/lib
    ../os/lib/: list.h ringBuffer.c ringBuffer.h symbolExport.h
  group aRTOS/arch
    ../os/arch/: hal_cm.c hal_cm.h platform.h hal_Support.c hal_Support.h
  group aRTOS/init
    ../os/init/: init.c
  group aRTOS_API
    ../os/: osAPI.h osConfig.h
  group nucleo-F767ZI
    ../os/arch/STM32F7xx/: stm32f7xx_nucleo_144.c stm32f7xx_nucleo_144.h
software components: CMSIS:CORE 5.0.0, CMSIS:DSP 1.4.6, Device:STM32Cube Framework:Classic 1.1.0, Device:STM32Cube HAL:Common 1.1.0, Device:STM32Cube HAL:Cortex 1.1.0, Device:STM32Cube HAL:GPIO 1.1.0, Device:STM32Cube HAL:PWR 1.1.0, Device:STM32Cube HAL:RCC 1.1.0, Device:Startup 1.1.0
